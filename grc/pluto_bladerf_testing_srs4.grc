options:
  parameters:
    author: Yutong Xin
    copyright: University of Torono Aerospace Team
    description: any <-> any
    generate_options: qt_gui
    id: pluto_bladerf_testing_srs4
    output_language: python
    title: Pluto BladeRF Testing Srs4
  states: {}

blocks:
- name: freq_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    label: Receiving Freq
    start: '432000000'
    step: '1'
    stop: '436000000'
    value: '433720000'
    widget: eng_slider
  states: {}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    label: Frequency Shift
    start: '-int(samp_rate/2)'
    step: '1'
    stop: int(samp_rate/2)
    value: '200000'
    widget: eng_slider
  states: {}
- name: freq_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    label: Transmitting Freq
    start: '432000000'
    step: '1'
    stop: '436000000'
    value: '433720000'
    widget: eng_slider
  states: {}
- name: msg
  id: variable
  parameters:
    value: '[1,2,3,4,5,6,7]'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: 200e3
    widget: eng_slider
  states: {}
- name: rx_gain_b
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Rx Gain Bladerf
    start: '-1'
    step: '1'
    stop: '60'
    value: '20'
    widget: eng_slider
  states: {}
- name: rx_gain_p
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: Rx Gain Pluto
    start: '0'
    step: '0.25'
    stop: '71'
    value: '0'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain_b
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Tx Gain Bladerf
    start: '17'
    step: '1'
    stop: '73'
    value: '20'
    widget: eng_slider
  states: {}
- name: tx_gain_p
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: Tx Gain Pluto
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
    widget: eng_slider
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: +int(freq_shift)
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(msg), msg))
    period: '500'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 89.75-tx_gain_p
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq_rx
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq_rx + freq_shift
    gain1: '''manual'''
    manual_gain1: rx_gain_p
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_rx
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_tx
    fftsize: '1024'
    name: '"tx"'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: BladeRF
    label1: PlutoSDR
    label2: TransmissionFrequency
    num_tabs: '3'
  states: {}
- name: satlab_srs4_rx_0_0
  id: satlab_srs4_rx
  parameters:
    auth: 'False'
    cc: 'True'
    constellation: QPSK
    crc: 'True'
    decrypt: 'False'
    idnum: '0'
    key: '"\x00" * 32'
    rand: 'True'
    rate: int(100e3)
    rolloff: '0.2'
    rs: 'True'
    samp_rate: samp_rate
    size: '217'
  states: {}
- name: satlab_srs4_tx_0
  id: satlab_srs4_tx
  parameters:
    auth: 'False'
    cc: 'True'
    constellation: QPSK
    crc: 'True'
    encrypt: 'False'
    idleframes: '10000'
    idnum: '0'
    key: '"\x00" * 32'
    max_in_flight: '100'
    rand: 'True'
    rate: int(100e3)
    rolloff: '0.2'
    rs: 'True'
    samp_rate: samp_rate
    size: '217'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq_tx
    gain: tx_gain_b
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq_rx + freq_shift
    gain: rx_gain_b
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_freqshift_cc_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', satlab_srs4_rx_0_0, '0']
- [blocks_message_strobe_0, strobe, satlab_srs4_tx_0, csp_in]
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0_0, '0']
- [satlab_srs4_rx_0_0, csp_out, blocks_message_debug_0, log]
- [satlab_srs4_tx_0, '0', iio_pluto_sink_0, '0']
- [satlab_srs4_tx_0, '0', qtgui_sink_x_1, '0']
- [satlab_srs4_tx_0, '0', soapy_bladerf_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_freqshift_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
