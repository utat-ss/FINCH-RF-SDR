options:
  parameters:
    author: Yutong
    copyright: University of Torono Aerospace Team
    generate_options: qt_gui
    id: bladerf_fm_radio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: listen_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,2,1
    label: Listen Frequency
    start: '88'
    step: '0.25'
    stop: '108'
    value: '98.7'
    widget: eng_slider
  states: {}
- name: rf_gain_bladerf
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: RF Gain BladeRF
    start: '-1'
    step: '1'
    stop: '60'
    value: '-1'
    widget: eng_slider
  states: {}
- name: rf_gain_pluto
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: RF Gain Pluto
    start: '0'
    step: '0.25'
    stop: '73'
    value: '0'
    widget: eng_slider
  states: {}
- name: rf_gain_rtl
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@2
    label: RF Gain RTL
    start: '-1'
    step: '1'
    stop: '60'
    value: '-1'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4e6)
  states: {}
- name: tune_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Tune Frequency
    start: '88'
    step: '0.25'
    stop: '108'
    value: '98.7'
    widget: eng_slider
  states: {}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate/20
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: (tune_frequency - listen_frequency)*(1e6)
    sample_rate: samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(tune_frequency*1e6)
    gain1: '''manual'''
    manual_gain1: rf_gain_pluto
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/20
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: BladeRF
    label1: PlutoSDR
    label2: RTL SDR
    num_tabs: '3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: (tune_frequency)*int(1e6)
    gain: rf_gain_bladerf
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: (tune_frequency)*int(1e6)
    gain: rf_gain_pluto
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: (tune_frequency)*int(1e6)
    gain: rf_gain_rtl
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_1, '0', rational_resampler_xxx_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
